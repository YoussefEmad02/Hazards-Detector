# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ADC.c ADC.h bitwise_operation.h cpu.c cpu.h DIO.c DIO.h Door.c Door.h Gpio_interrupt.c Gpio_interrupt.h GPTM.c GPTM.h HC-05.c HC-05.h HC-SR04.c HC-SR04.h interrupt.c interrupt.h LCD.c LCD.h LM35.c LM35.h main.c PWM.c PWM.h sysctl.c sysctl.h Systic_timer.c Systic_timer.h systick.c systick.h timer.c timer.h tm4c123gh6pm.h types.h UART.c UART.h
